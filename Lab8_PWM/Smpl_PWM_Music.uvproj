# Keil uVision project Smpl_PWM_Music.uvproj, settings and files
target Smpl_PWM_Music (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_PWM_Tone
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\CM0\CoreSupport;.\Include\Driver;.\Include\NUC1xx-LB_002;.\Src\Driver;.\Src\NUC1xx-LB_002;.\CM0\DeviceSupport\Nuvoton\NUC1xx;.\Include
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ./CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
    ./CM0/CoreSupport/: core_cm0.c
  group Source files
    ./: Smpl_PWM_Music.c
    ./Src/NUC1xx-LB_002/: Ascii_Table.c LCD_Driver.c
  group Library files
    ./Src/Driver/: DrvGPIO.c DrvSYS.c
