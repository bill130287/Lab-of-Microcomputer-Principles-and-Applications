# Keil uVision project Smpl_7seg_Keypad.uvproj, settings and files
target Smpl_7seg_Keypad (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_7seg_Keypad
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\CM0\DeviceSupport\Nuvoton\NUC1xx;.\Include;.\Include\Driver;.\;.\Src\Driver;.\CM0\CoreSupport
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./CM0/CoreSupport/: core_cm0.c
    ./CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ./CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: Smpl_7seg_Keypad.c
    ./Src/NUC1xx-LB_002/: Ascii_Table.c
  group Library files
    ./Src/Driver/: DrvGPIO.c DrvSYS.c
