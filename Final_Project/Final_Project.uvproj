# Keil uVision project Final_Project.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Timer
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\CM0\DeviceSupport\Nuvoton\NUC1xx;.\Include;.\Include\Driver;.\;.\Src\Driver;.\CM0\CoreSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group Startup
    ./: startup_NUC1xx.s
    ./CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ./CM0/CoreSupport/: core_cm0.c
  group Main
    ./: LAB_LCD.c
  group NUC140_Driver
    ./Src/Driver/: DrvSYS.c DrvGPIO.c
    ./Src/NUC1xx-LB_002/: LCD_Driver.c Ascii_Table.c
