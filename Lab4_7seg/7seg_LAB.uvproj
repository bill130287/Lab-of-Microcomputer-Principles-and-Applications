# Keil uVision project 7seg_LAB.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: 7seg_answer
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\CM0\DeviceSupport\Nuvoton\NUC1xx;.\Include;.\Include\Driver;.\;.\Src\Driver;.\CM0\CoreSupport
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ./: startup_NUC1xx.s
    ./CM0/CoreSupport/: core_cm0.c
    ./CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
  group Main
    ./: 7seg.c
  group NUC140_Driver
    ./Src/Driver/: DrvGPIO.c DrvSYS.c
